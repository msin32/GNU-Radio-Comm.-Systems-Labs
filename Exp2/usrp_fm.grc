options:
  parameters:
    author: Erik & Mohsin
    description: Creating a receiver in order to listen to FM radio stations
    generate_options: qt_gui
    id: usrp_fm
    output_language: python
    title: Simple SDR FM Receiver
  states: {}

blocks:
- name: audio_interp
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '4'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '99700000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_interp
    quad_rate: audio_interp*audio_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw
    ok_to_block: 'False'
    samp_rate: audio_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '768'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    dev_addr: addr=192.168.20.2
    gain0: gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
