options:
  parameters:
    author: Erik and Mohsin
    category: ECE440
    description: A block for calculating average power of a signal.
    generate_options: qt_gui
    id: IdealCommSystem
    output_language: python
    title: Power
  states: {}

blocks:
- name: noise_ampl
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: signal_ampl
  id: variable_qtgui_range
  parameters:
    label: Signal Amplitude
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_ampl
    noise_type: analog.GR_GAUSSIAN
    seed: '10804'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: signal_ampl
    freq: '1200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1250'
    low_cutoff_freq: '1150'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '5'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: power_0
  id: power
  parameters: {}
  states: {}
- name: power_1
  id: power
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Filtered Signal
    label2: Noisy Signal
    name: '"Filtered Cosine Frequency Domain"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Average Noise Power
    max: '5'
    min: '0'
    type: float
    unit1: W
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Average Signal Power
    max: '5'
    min: '0'
    type: float
    unit1: W
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: SNR
    max: '5'
    min: '0'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,2
    label1: '"Filtered Signal"'
    label2: '"Noisy Signal"'
    name: '"Filtered Cosine Time Domain"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', power_1, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', power_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_divide_xx_0, '0', qtgui_number_sink_0_1, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']
- [power_0, '0', blocks_divide_xx_0, '0']
- [power_0, '0', qtgui_number_sink_0_0, '0']
- [power_1, '0', blocks_divide_xx_0, '1']
- [power_1, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
