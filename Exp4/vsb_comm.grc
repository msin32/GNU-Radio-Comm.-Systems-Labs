options:
  parameters:
    generate_options: qt_gui
    id: dsb_comm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: noise
  id: variable_qtgui_range
  parameters:
    label: noise
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '200000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/shay/a/ekocinar/ECE440/Lab4/audiotest2.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '200000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '40000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: power_0
  id: power
  parameters: {}
  states: {}
- name: power_0_0
  id: power
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '15'
    min: '0'
    name: '"SNR"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', power_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_divide_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_xx_0, '0', high_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_0, '0']
- [blocks_wavfile_source_0, '0', power_0_0, '0']
- [high_pass_filter_0, '0', blocks_add_xx_0, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [high_pass_filter_0, '0', qtgui_time_sink_x_0, '1']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_0, '1']
- [power_0, '0', blocks_divide_xx_0, '1']
- [power_0_0, '0', blocks_divide_xx_0, '0']

metadata:
  file_format: 1
