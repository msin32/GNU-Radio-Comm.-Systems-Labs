options:
  parameters:
    author: Erik & Mohsin
    description: Receiving AM signals.
    generate_options: qt_gui
    id: am_comm
    output_language: python
    title: '"AM Communications"'
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '1'
  states: {}
- name: a
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: fc
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '10000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '109'
    step: '0.05'
    stop: '130'
    value: '119.6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '0.1'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw
    ok_to_block: 'False'
    samp_rate: audio_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-(Ac**2)*(1+a**2/2)/2'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '6000'
    decim: int(samp_rate / audio_rate)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '6000'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: audio_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq * 1000000
    dev_addr: addr=192.168.20.2
    gain0: '50'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_add_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', low_pass_filter_0_0_0, '0']
- [low_pass_filter_0_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_add_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
